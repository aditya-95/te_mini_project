Commit message: added limit checking

File: src/ik/urdf/manipulator2.urdf (robot description, URDF)
Before this commit: robot manipulator, 7 links, 6 joints
Joints:
- joint l1_to_l2: limit lower=-3.1 upper=3.1 effort=0.1 velocity=0.2 -> lower=-1.57 upper=1.57 effort=0.1 velocity=0.2
